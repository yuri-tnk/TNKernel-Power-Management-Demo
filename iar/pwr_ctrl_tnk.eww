<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwr_ctrl_tnk.ewp</path>
    </project>
    <batchBuild />
</workspace>
