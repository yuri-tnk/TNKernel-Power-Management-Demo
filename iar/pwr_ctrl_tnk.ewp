# IAR project pwr_ctrl_tnk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..; ..\os
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ..
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5359.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: buttons_leds.c deep_sleep.c dt.h hardware_init.c ltt.c main.c pmm.c rtc.c shell.c test_shell_func.c tn_sprintf.c tn_user.c uart.c utils.c
  group Header_files
    ../: data_externals.h func_prototypes.h pmm.h prj_conf.h tn_config.h types.h uart.h
  group os
    ../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
    ../os/MSP430X/: tn_port_MSP430X.asm tn_port_MSP430X_iar.c
