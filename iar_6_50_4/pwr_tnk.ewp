# IAR project pwr_tnk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5359 MSP430F5359
  General.GStackSize2: 512
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.IExtraOptions: --diag_suppress=Pa050
  ICC430.newCCIncludePaths: ..; ..\os
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ..
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5359.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -Omsp430_txt=.txt
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 160
  ICC430.CCDefines: xdc_target_types__=c:\ti\xdctools_3_25_04_88\packages\iar\targets\msp430\std.h
  ICC430.newCCIncludePaths: c:\ti\xdctools_3_25_04_88\packages; c:\ti\bios_6_37_00_20\packages; ..\..\leak_buster\include; ..\..\leak_buster\logical_drv\gsm_ld\include; ..\..\leak_buster\logical_drv\trm_ld\include; ..\..\leak_buster\logical_drv\panel_ld\include; ..\..\leak_buster\utilities\include; ..\..\leak_buster\apps\include; ..\..\leak_buster\logical_drv\include; ..\..\leak_buster\logical_drv\gsm_ld\include; ..\..\leak_buster\bsp\include; ..\..\leak_buster\ll_driver\include; ..\..\leak_buster\managers\include; ..\..\leak_buster\os\include; ..\..\leak_buster\sub_sys\include; ..\..\leak_buster\utilities\include; ..\..\leak_buster\managers\algo_manager\include; ..\..\leak_buster\fs\config; ..\..\leak_buster\fs\core
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: ..\..\iar\sysbios\configPkg\linker.opt
  group (top)
    ../: buttons_leds.c deep_sleep.c hardware_init.c ltt.c main.c pmm.c rtc.c shell.c test_shell_func.c tn_sprintf.c tn_user.c uart.c utils.c
  group Headers
    ../: data_externals.h dt.h func_prototypes.h pmm.h prj_conf.h tn_config.h types.h uart.h
  group os
    ../os/: tn.c tn.h tn_alloc.c tn_dqueue.c tn_event.c tn_mailbox.c tn_mem.c tn_mutex.c tn_port.h tn_sem.c tn_sys.c tn_task.c tn_timer.c tn_utils.c tn_utils.h
    ../os/MSP430X/: tn_port_MSP430X.asm tn_port_MSP430X_iar.c
